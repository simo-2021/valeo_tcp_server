## base_external/package/valeo-ecu/Config.in
```kconfig
config BR2_PACKAGE_VALEO_ECU
	bool "valeo-ecu"
	help
	  Simulation of an  ECU  (TCP server).
	  
```
